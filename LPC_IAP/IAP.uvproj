# Keil uVision project IAP.uvproj, settings and files
target IAP (ARM-ADS)
  device: LPC2132 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: IAP
  c flags: Optim=1 OneElfS=1
  c include: .\INC;.\MyDrivers;..\LPC_IAP
  asm include: .\INC
  memory RVCT4: ROM 0x0 size 0x3000
  memory RVCT9: RAM 0x40000000 size 0x3fe0
  group USER
    ./: main.c
  group CORE
    ./: Startup.s
  group FWLib
    ./SRC/: lib_e2prom_lpc213x.c lib_vic_lpc213x.c lib_scb_lpc213x.c lib_gpio_lpc213x.c lib_uart_lpc213x.c lib_spi_lpc213x.c lib_watchdog_lpc213x.c
  group MyDrivers
    ./MyDrivers/: PeripProtocol.c HostProtocol.c CRC.c LED.c WD.c
